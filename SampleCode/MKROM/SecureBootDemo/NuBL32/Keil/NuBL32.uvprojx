# Keil uVision project NuBL32.uvprojx, settings and files
target NuBL32 (6100001::V6.10.1::.\ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: NuBL32
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L"
  AfterMake: FwSign NuBL32\NuBL32.bin NuBL32\FwInfo.bin 0x38000
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT=UART0
  c include: ..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\NuBL32
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\NuBL32.sct
  link misc: --map --first='startup_M261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
 --keep=FwInfo.o(*)
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
    ../../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
  group User
    ../: main.c
    ../FwInfo/: FwInfo.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c MKROMLib_Keil.lib
