# Keil uVision project NuBL32.uvprojx, settings and files
target NuBL32 (6100001::V6.10.1::.\ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: NuBL32_FW +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: FwSign.exe .\NuBL32_FW.bin\FLASH .\NuBL32_FW.bin\FWINFO 0x5E000
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\common\inc;..\..\NuBL32;..\..\NuBL2\ota;..\..\..\..\..\ThirdParty\FatFs\src;..\..\NuBL2\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\NuBL32.sct
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
    ../: NuBL32_startup_M261.s
  group User
    ../: NuBL32_main.c NuBL32_FwInfo.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c sys.c uart.c fmc.c sdh.c gpio.c clk.c MKROMLib_Keil.lib
    ../../NuBL2/lib/: NuBL2lib.c
