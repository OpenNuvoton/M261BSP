# Keil uVision project NuBL2.uvprojx, settings and files
target NuBL2_OTA_Client (6220000::V6.22::ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: NuBL2_FW
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: AfterBuild.bat
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c misc: -Wno-single-bit-bitfield-constant-conversion -Wno-bitfield-constant-conversion -Wno-unknown-warning-option
  c include: ..\..\common\inc;..\..\NuBL2;..\..\Esp8266Lib;..\..\..\..\..\ThirdParty\FatFs\src;..\ota;..\esp;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\NuBL2.sct
  link misc: --keep=NuBL2_lib0.o(*) --keep=NuBL_crypto.o(*) --keep=ota.o(*)
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
    ../: NuBL2_startup_M261.s
  group User
    ../: NuBL2_main.c NuBL2_FWinfo.c NuBL2_lib0.c
    ../keyInfo/: LoadKeyStorage.s
  group Common
    ../../common/src/: NuBL_crypto.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c sys.c uart.c fmc.c sdh.c MKROMLib_Keil.lib
    ../: my_clk.c
  group ESP
    ../../Esp8266Lib/: buffer.c esp8266.c
    ../esp/: esp8266_ll.c
  group FATFS
    ../../../../../ThirdParty/FatFs/src/: ff.c
    ../Fs/: diskio.c SDGlue.c
  group OTA
    ../ota/: ota.c ota_api.c ota_transfer.c
