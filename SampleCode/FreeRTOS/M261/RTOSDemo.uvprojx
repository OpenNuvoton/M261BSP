# Keil uVision project RTOSDemo.uvprojx, settings and files
target M261 (6070000::V6.7::.\ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo
  c flags: v6Lang=5 wLevel=1
  c include: ..\M261;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\Library\CMSIS\Include;.\Keil_Specific;..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\Library\StdDriver\inc;..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_V8M
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\secure.sct
  group System
    ./: partition_M261.h
    ../../../Library/StdDriver/src/: sys.c retarget.c clk.c
    ../../../Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
    ../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
  group FreeRTOS source
    ../../../ThirdParty/FreeRTOS/Source/: timers.c list.c queue.c tasks.c
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_V8M/: port.c
  group Demo App Source
    ./: main.c main-blinky.c FreeRTOSConfig.h main-full.c ParTest_M261.c RegTest_Keil.s
  group Common Demo Tasks
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c
