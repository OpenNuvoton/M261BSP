# IAR project FreeRTOS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M261 series Nuvoton M261 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M261\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM0; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: FreeRTOS.bin
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkIcfFile: m261.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Common Demo Tasks
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: blocktim.c countsem.c dynamic.c QueueOverwrite.c QueueSet.c recmutex.c
  group Demo App Source
    ../: FreeRTOSConfig.h main-blinky.c main-full.c main.c ParTest_M261.c
    ./: RegTest_IAR.s
  group FreeRTOS source
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group System
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c
    ../: partition_M261.h
    ../../../../Library/Device/Nuvoton/M261/Source/IAR/: startup_M261.s
    ../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
