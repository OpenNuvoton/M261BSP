# Keil uVision project RTOSDemo.uvprojx, settings and files
target TicklessIdle (6180000::V6.18::ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM0;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group System
    ../../../../Library/StdDriver/src/: sys.c retarget.c clk.c uart.c rtc.c gpio.c
    ../../../../Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
    ../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
  group FreeRTOS source
    ../../../../ThirdParty/FreeRTOS/Source/: timers.c list.c queue.c tasks.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Demo App Source
    ../: main.c FreeRTOSConfig.h port.c ParTest.c
  group Common Demo Tasks
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c
