# Keil uVision project FMC_DualBankBoot.uvprojx, settings and files
target FMC_DualBankBoot (6100001::V6.10.1::.\ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: FMC_DualBankBoot
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group User
    ../: main.c
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
    ../../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
  group Library
    ../../common/src/: NuDB_common.c
    ../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c wdt.c uart.c
