# Keil uVision project SC_ReadSIM_PhoneBook.uvprojx, settings and files
target SC_ReadSIM_PhoneBook (6070000::V6.7::.\ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: SC_ReadSIM_PhoneBook
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
    ../../../../Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c sc.c
    ../../../../Library/SmartcardLib/: SmartCardLib_Keil.lib
