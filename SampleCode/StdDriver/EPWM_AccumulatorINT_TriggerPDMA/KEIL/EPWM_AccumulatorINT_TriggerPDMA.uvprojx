# Keil uVision project EPWM_AccumulatorINT_TriggerPDMA.uvprojx, settings and files
target EPWM_AccumulatorINT_TriggerPDMA (6060000::V6.6::.\ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: EPWM_AccumulatorINT_TriggerPDMA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
    ../../../../Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c pdma.c epwm.c
