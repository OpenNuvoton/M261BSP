# IAR project USBH_UAC_HID.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M261 series Nuvoton M261 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M261\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_UAC_HID.bin
  ILINK.IlinkOutputFile: USBH_UAC_HID.out
  ILINK.IlinkIcfFile: m261.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M261/Source/IAR/: startup_M261.s
    ../../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c uart.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_HID
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
  group UsbHostLib_UAC
    ../../../../Library/UsbHostLib/src_uac/: uac_core.c uac_driver.c uac_parser.c
  group User
    ../: main.c
